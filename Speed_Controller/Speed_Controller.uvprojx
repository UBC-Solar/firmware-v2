# Keil uVision project Speed_Controller.uvprojx, settings and files
target Main (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Speed_Controller
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Peripherals\CAN;..\Peripherals\virtual_com
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c
  group Peripherals
    ../Peripherals/CAN/: CAN.c CAN.h
    ../Peripherals/virtual_com/: virtual_com.c virtual_com.h
  group ADC
    ./src/ADC/: ADC.h ADC.c
  group Encoder
    ./src/Encoder/: encoder.c encoder.h
  group Timer
    ./src/Timer/: Timer.c Timer.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
